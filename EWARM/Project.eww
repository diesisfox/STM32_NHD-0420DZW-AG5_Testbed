<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_NHD-0420DZW-AG5_Testbed.ewp</path>
  </project>
  <batchBuild />
</workspace>
